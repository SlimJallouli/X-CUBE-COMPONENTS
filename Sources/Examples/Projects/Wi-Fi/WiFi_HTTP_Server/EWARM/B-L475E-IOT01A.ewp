# IAR project B-L475E-IOT01A.ewp, settings and files
configuration B-L475E-IOT01A (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx
  ICCARM.CCIncludePath2: ../Inc; C:/Users/slim jallouli/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.1/Drivers/STM32L4xx_HAL_Driver/Inc; C:/Users/slim jallouli/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.1/Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; C:/Users/slim jallouli/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.1/Drivers/CMSIS/Device/ST/STM32L4xx/Include; C:/Users/slim jallouli/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.1/Drivers/CMSIS/Include; C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-COMPONENTS/1.3.4/Middleware/ST/Sensors/Environmental/HTS221; C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-COMPONENTS/1.3.4/Middleware/ST/Sensors/Environmental/HTS221/I2C/Inc; C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-COMPONENTS/1.3.4/Middleware/ST/Board Part/BUTTON/GPIO; C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-COMPONENTS/1.3.4/Middleware/ST/Wi-Fi/ISM43362; C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-COMPONENTS/1.3.4/Middleware/ST/Wi-Fi/ISM43362/SPI; C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-COMPONENTS/1.3.4/Middleware/ST/Board Part/LED/GPIO; ../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../Drivers/CMSIS/Include; ../../../../Middlewares/ST/Components/Sensors/Environmental/HTS221; ../../../../Middlewares/ST/Components/Sensors/Environmental/HTS221/I2C/Inc; ../../../../Middlewares/ST/Components/BUTTON/GPIO; ../../../../Middlewares/ST/Components/LED/GPIO; ../../../../Middlewares/ST/Components/Wi-Fi/ISM43362; ../../../../Middlewares/ST/Components/Wi-Fi/ISM43362/SPI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: B-L475E-IOT01A.hex
  ILINK.IlinkOutputFile: B-L475E-IOT01A.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../Src/: app.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/Components/Button/Button/GPIO
    ../../../../Middlewares/ST/Components/BUTTON/GPIO/: button.c button.h
  group Middlewares/Components/LED/LED/GPIO
    ../../../../Middlewares/ST/Components/LED/GPIO/: led.h
  group Middlewares/Sensors/Environmental/Environmental/HTS221/I2C
    ../../../../Middlewares/ST/Components/Sensors/Environmental/HTS221/: hts221.c hts221.h humidity_sensor.h temperature_sensor.h
    ../../../../Middlewares/ST/Components/Sensors/Environmental/HTS221/I2C/Inc/: hts221_reg.h
    ../../../../Middlewares/ST/Components/Sensors/Environmental/HTS221/I2C/Src/: hts221_reg_i2c.c
  group Middlewares/STDIO/Compiler/I O/STDOUT/USART
    ../../../../Middlewares/ST/STDIO/: stdout_usart.c
  group Middlewares/Wireless/Wi-Fi/Wi-Fi/ISM43362/SPI
    ../../../../Middlewares/ST/Components/Wi-Fi/ISM43362/: es_wifi.c es_wifi.h es_wifi_conf.h wifi.c wifi.h
    ../../../../Middlewares/ST/Components/Wi-Fi/ISM43362/SPI/: es_wifi_io.c es_wifi_io.h
