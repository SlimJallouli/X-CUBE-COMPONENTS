# IAR project B-L475E-IOT01A.ewp, settings and files
configuration B-L475E-IOT01A (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/Components/Sensors/LSM6DSL/I2C; ../../../../../Middlewares/ST/Components/Sensors/LSM6DSL; ../../../../../Middlewares/ST/Components/Sensors/Environmental/HTS221; ../../../../../Middlewares/ST/Components/Sensors/Environmental/HTS221/I2C/Inc; ../../../../../Middlewares/ST/Components/Sensors/Motion/LIS3MDL; ../../../../../Middlewares/ST/Components/Sensors/Motion/LIS3MDL/I2C; ../../../../../Middlewares/ST/Components/Sensors/Motion/LPS22HB; ../../../../../Middlewares/ST/Components/Sensors/Motion/LPS22HB/I2C; ../../../../../Middlewares/ST/Components/LED/GPIO
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: B-L475E-IOT01A.hex
  ILINK.IlinkOutputFile: B-L475E-IOT01A.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../Src/: app.c main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/STDIO/Compiler/I O/STDOUT/USART
    ../../../../../Middlewares/ST/STDIO/: stdout_usart.c
  group Middlewares/Sensors/Motion/GYRO/LSM6DSL/I2C
    ../../../../../Middlewares/ST/Components/Sensors/LSM6DSL/I2C/: lsm6dsl_reg.h lsm6dsl_reg.c
    ../../../../../Middlewares/ST/Components/Sensors/LSM6DSL/: accel_gyro_sensor.h accelerometer.h gyroscope.h lsm6dsl.h lsm6dsl.c
  group Middlewares/Sensors/Environmental/Environmental/HTS221/I2C
    ../../../../../Middlewares/ST/Components/Sensors/Environmental/HTS221/: hts221.h humidity_sensor.h temperature_sensor.h hts221.c
    ../../../../../Middlewares/ST/Components/Sensors/Environmental/HTS221/I2C/Inc/: hts221_reg.h
    ../../../../../Middlewares/ST/Components/Sensors/Environmental/HTS221/I2C/Src/: hts221_reg_i2c.c
  group Middlewares/Sensors/Motion/Mag/LIS3MDL/I2C
    ../../../../../Middlewares/ST/Components/Sensors/Motion/LIS3MDL/: lis3mdl.h mag_sensor.h lis3mdl.c
    ../../../../../Middlewares/ST/Components/Sensors/Motion/LIS3MDL/I2C/: lis3mdl_reg.h lis3mdl_reg.c
  group Middlewares/Sensors/Motion/BAR/LPS22HB/I2C
    ../../../../../Middlewares/ST/Components/Sensors/Motion/LPS22HB/: lps22hb.h barometer_sensor.h lps22hb.c
    ../../../../../Middlewares/ST/Components/Sensors/Motion/LPS22HB/I2C/: lps22hb_reg.h lps22hb_reg.c
  group Middlewares/Components/LED/LED/GPIO
    ../../../../../Middlewares/ST/Components/LED/GPIO/: led.h
