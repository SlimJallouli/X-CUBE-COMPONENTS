<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\B-L475E-IOT01A.ewp</path>
  </project>
  <batchBuild />
</workspace>
