# IAR project STM32F746ZG_NUCLEO.ewp, settings and files
configuration STM32F746ZG_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../Drivers/STM32F7xx_HAL_Driver/Inc; ../../../../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../../../../Drivers/CMSIS/Include; ../../../../Middlewares/ST/Components/LCD/Grove; ../../../../Middlewares/ST/Components/LCD/Grove/I2C
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F746ZG_NUCLEO.hex
  ILINK.IlinkOutputFile: STM32F746ZG_NUCLEO.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_exti.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Middlewares/STDIO/Compiler/I O/STDOUT/LCD
    ../../../../Middlewares/ST/STDIO/: stdout_lcd.c
  group Middlewares/STDIO/Compiler/I O/STDIN/USART
    ../../../../Middlewares/ST/STDIO/: stdin_usart.c
  group Middlewares/Display/LCD/LCDController/Grove/I2C
    ../../../../Middlewares/ST/Components/LCD/Grove/: LCD.h
    ../../../../Middlewares/ST/Components/LCD/Grove/I2C/: easy_rgb_lcd.h easy_rgb_lcd.c
