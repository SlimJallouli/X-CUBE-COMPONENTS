# IAR project STM32F746ZG_NUCLEO.ewp, settings and files
configuration STM32F746ZG_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ../Inc; C:/Users/slim jallouli/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.0/Drivers/STM32F7xx_HAL_Driver/Inc; C:/Users/slim jallouli/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.0/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; C:/Users/slim jallouli/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.0/Drivers/CMSIS/Device/ST/STM32F7xx/Include; C:/Users/slim jallouli/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.0/Drivers/CMSIS/Include; C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-COMPONENTS/1.2.3/Middleware/ST/LCD/Grove; C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-COMPONENTS/1.2.3/Middleware/ST/LCD/Grove/I2C
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F746ZG_NUCLEO.hex
  ILINK.IlinkOutputFile: STM32F746ZG_NUCLEO.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    C:/Users/slim jallouli/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_exti.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/STDIO/Compiler/I O/STDOUT/LCD
    C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/I-CUBE-STDIO/1.4.0/Middleware/ST/STDIO/: stdout_lcd.c
  group Middlewares/STDIO/Compiler/I O/STDIN/USART
    C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/I-CUBE-STDIO/1.4.0/Middleware/ST/STDIO/: stdin_usart.c
  group Middlewares/LCD/Components/LCDController/Grove/I2C
    C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-COMPONENTS/1.2.3/Middleware/ST/LCD/Grove/: LCD.h
    C:/Users/slim jallouli/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-COMPONENTS/1.2.3/Middleware/ST/LCD/Grove/I2C/: easy_rgb_lcd.h easy_rgb_lcd.c
